# Keil uVision project OLED.uvprojx, settings and files
target oled (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\CORE;..\FREERTOS\portable\RVDS\ARM_CM3;..\FREERTOS\include;..\USER;..\FWLIB\Inc;..\SYSTEM\usart;..\SYSTEM\sys;..\SYSTEM\memory;..\SYSTEM\delay;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\1.8tft;..\HARDWARE\ADC;..\HARDWARE\KEY;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c freertos_demo.c system_stm32f1xx.c stm32f10x_it.c
  group CORE
    ../CORE/: startup_stm32f103xb.s
  group FREERTOS/port
    ../FREERTOS/portable/MemMang/: heap_4.c
    ../FREERTOS/portable/RVDS/ARM_CM3/: port.c
  group FREERTOS/src
    ../FREERTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FWLIB
    ../FWLIB/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_sram.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/memory/: mem_mgr.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/1.8tft/: GUI.c Lcd_Driver.c QDTFT_demo.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: gtim.c
    ../HARDWARE/WIFI/: esp01_driver.c
